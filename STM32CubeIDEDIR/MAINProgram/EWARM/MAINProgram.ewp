# IAR project MAINProgram.ewp, settings and files
configuration MAINProgram (ARM, debug)
  General.OGChipSelectEditMenu: STM32G031K8 ST STM32G031K8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G031xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; C:\Users\chels\OneDrive - NAIT\term 4\CPME-2750 (Carlos)\Main_GIthub\cmpe2750-hardware-1242-a03-NareshKoirala\STM32CubeIDEDIR\MAINProgram\Drivers\MAX30100; C:\Users\chels\OneDrive - NAIT\term 4\CPME-2750 (Carlos)\Main_GIthub\cmpe2750-hardware-1242-a03-NareshKoirala\STM32CubeIDEDIR\MAINProgram\Drivers\OLED
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MAINProgram.hex
  ILINK.IlinkOutputFile: MAINProgram.out
  ILINK.IlinkIcfFile: stm32g031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g031xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_hal_msp.c stm32g0xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/MAX30100
    ../Drivers/MAX30100/: max30100_for_stm32_hal.c max30100_for_stm32_hal.h
  group Drivers/OLED
    ../Drivers/OLED/: ssd1306.c ssd1306.h ssd1306_conf.h ssd1306_fonts.c ssd1306_fonts.h
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_rcc.c
